<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\LT_KeShe_B.ewp</path>
  </project>
  <batchBuild />
</workspace>
